## hello-android/hello-android-driver/Kconfig
```kconfig
config HA
  tristate "Hello Android Driver"
  default n
  help
  This is the ha driver for android system.
```
